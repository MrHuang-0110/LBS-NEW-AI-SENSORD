# Keil uVision project HK32_ELECTROMAGNETIC_SENSOR.uvprojx, settings and files
target HK32_ELECTROMAGNETIC_SENSOR (6240000::V6.24::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ELECTROMAGNETIC_SENSOR +hex
  AfterMake: D:\MDK\ARM\ARMCLANG\bin\fromelf.exe --bin -o .\Objects\ELECTROMAGNETIC_SENSOR\ELECTROMAGNETIC_SENSOR.bin .\Objects\ELECTROMAGNETIC_SENSOR\ELECTROMAGNETIC_SENSOR.axf
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HK32F030M,HK32F030MF4P6,ELECTROMAGNETIC_SENSOR=1
  c include: ..\Source\Libraries\HK32F030M_Lib\inc;..\Source\Libraries\HK32F030M_Lib\src;..\Source\Libraries\CMSIS\CM0\Core;..\Source\Libraries\CMSIS\CM0;..\Source\Libraries\CMSIS\HK32F030M\Include;..\Source\Libraries\CMSIS\HK32F030M\Source;..\Source\User;..\Source\User\led;..\Source\Handware\dataAnalysisProtocol;..\Source\Handware\queue;..\Source\Handware\USART;..\Source\Handware\TIMER;..\Source\Handware\PWM;..\Source\Handware\SysTick;..\Project;..\Source\Handware\ltr381xx;..\Source\Handware\IIC
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../Source/User/: hk32f030m_it.c main.c
    ../Source/Handware/dataAnalysisProtocol/: data_analysis.c
    ../Source/Handware/queue/: queue.c
    ../Source/Handware/USART/: usart.c
    ./: senords.c senords.h
    ../Source/Handware/TIMER/: timer.c
    ../Source/Handware/PWM/: pwm.c
    ../Source/Handware/SysTick/: systick_delay.c
    ../Source/Handware/ltr381xx/: ltr381xx.c
    ../Source/Handware/IIC/: bsp_i2c.c
  group StdPeriph_Driver
    ../Source/Libraries/HK32F030M_Lib/src/: hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
  group CMSIS
    ../Source/Libraries/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group Startup
    ../Source/Libraries/CMSIS/HK32F030M/Source/: KEIL_Startup_hk32f030m.s
  group Doc
    ../Doc/: Readme.txt
