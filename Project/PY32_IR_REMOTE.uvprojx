# Keil uVision project PY32_IR_REMOTE.uvprojx, settings and files
target PY32_IR_REMOTE (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IR_REMOTE +hex
  AfterMake: D:\MDK\ARM\ARMCLANG\bin\fromelf.exe --bin -o .\Objects\IR_REMOTE\IR_REMOTE.bin .\Objects\IR_REMOTE\IR_REMOTE.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5,IR_REMOTE=1
  c include: ..\PY32\App\ir_remote;..\PY32\Core;..\PY32\HAL\PY32F002B_HAL_Driver\Inc;..\PY32\HAL\CMSIS\Include;..\PY32\HAL\CMSIS\Device\PY32F0xx\Include;..\Project
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Application/Core
    ../PY32/Core/: startup_py32f002xx.s system_py32f002b.c
    ../PY32/App/ir_remote/: main.c gpio.c usart.c tim.c adc.c ir_proto.c driver_ir.c agreement_comx.c rx_data_queue.c py32f002b_hal_msp.c py32f002b_it.c main.h
  group Drivers/PY32F002B_HAL_Driver
    ../PY32/HAL/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group Drivers/CMSIS
    ../PY32/App/ir_remote/: py32f002b_hal_conf.h
  group Doc
    ../Doc/: Readme.txt
