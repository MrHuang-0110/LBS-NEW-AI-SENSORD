# Keil uVision project STM32_NFC.uvprojx, settings and files
target STM32_NFC (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: NFC_G030F6 +hex
  AfterMake: D:\MDK\ARM\ARMCLANG\bin\fromelf.exe --bin -o .\Objects\NFC_G030F6\NFC_G030F6.bin .\Objects\NFC_G030F6\NFC_G030F6.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32G030xx,NFC_G030F6=1
  c include: ..\G0\App\nfc;..\G0\App\nfc\user;..\G0\Core;..\G0\HAL\STM32G0xx_HAL_Driver\Inc;..\G0\HAL\STM32G0xx_HAL_Driver\Inc\Legacy;..\G0\HAL\CMSIS\Device\ST\STM32G0xx\Include;..\G0\HAL\CMSIS\Include;..\Project
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/Core
    ../G0/Core/: startup_stm32g030xx.s system_stm32g0xx.c
    ../G0/App/nfc/: main.c gpio.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c rc522.c
    ../G0/App/nfc/user/: data_analysis.c queue.c
  group Drivers/STM32G0xx_HAL_Driver
    ../G0/HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../G0/App/nfc/: stm32g0xx_hal_conf.h
