# Keil uVision project STM32_GRAY_V2.uvprojx, settings and files
target STM32_GRAY_V2 (6240000::V6.24::ARMCLANG)
  device: STM32G030K6Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: GRAY_V2 +hex
  AfterMake: D:\MDK\ARM\ARMCLANG\bin\fromelf.exe --bin -o .\Objects\GRAY_V2\GRAY_V2.bin .\Objects\GRAY_V2\GRAY_V2.axf
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,GRAY_V2=1
  c include: ..\G0\App\gray_v2;..\G0\Core;..\G0\HAL\STM32G0xx_HAL_Driver\Inc;..\G0\HAL\STM32G0xx_HAL_Driver\Inc\Legacy;..\G0\HAL\CMSIS\Device\ST\STM32G0xx\Include;..\G0\HAL\CMSIS\Include;..\Project
  asm include: as above
  memory RVCT4: ROM 0x8003800 size 0x4600
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/Core
    ../G0/Core/: startup_stm32g030xx.s system_stm32g0xx.c
    ../G0/App/gray_v2/: main.c adc.c dma.c gpio.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c agreement_comx.c driver_gray.c driver_sys.c stmflash.c rx_data_queue.c
  group Drivers/STM32G0xx_HAL_Driver
    ../G0/HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c
  group Drivers/CMSIS
    ../G0/App/gray_v2/: stm32g0xx_hal_conf.h
